File: PSU.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: add impedance spec in the datasheet
